# IAR project stm8L_iButton.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL; USE_STDPERIPH_DRIVER; USE_HALT; UNUSE_DIO_0
  ICCSTM8.CCIncludePath2: spl; 
  ICCSTM8.IccLang: 2
  OBJCOPY.OOCOutputFile: stm8L_iButton.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: Checksum.cpp Checksum.h eeprom.cpp eeprom.h JLora.cpp JLora.h JRfm95.cpp JRfm95.h JSpi.cpp JSpi.h Lancher.cpp Lancher.h main.cpp main.h parser42.cpp parser42.h rfClient.cpp rfClient.h Rfm95Header.h Serial.cpp Serial.h SpiStm8l051.cpp SpiStm8l051.h stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h timerJ.cpp timerJ.h utils.cpp utils.h varInEeprom.cpp varInEeprom.h
  group spl
    spl/: stm8l15x.h stm8l15x_clk.c stm8l15x_clk.h stm8l15x_exti.c stm8l15x_exti.h stm8l15x_flash.c stm8l15x_flash.h stm8l15x_gpio.c stm8l15x_gpio.h stm8l15x_rtc.c stm8l15x_rtc.h stm8l15x_spi.c stm8l15x_spi.h stm8l15x_tim4.c stm8l15x_tim4.h stm8l15x_usart.c stm8l15x_usart.h
